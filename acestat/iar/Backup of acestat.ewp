# IAR project Backup of acestat.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ADuCM355 AnalogDevices ADuCM355
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: CHIPSEL_M355
  ICCARM.CCIncludePath2: ..\..\aducm355-examples\inc; ..\..\aducm355-examples\common; ..\..\aducm355-examples\common\ad5940lib; ..\src; ..\src\chemcrab_lib
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: ADuCM355_SRAM_Mode2.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group application
    ../src/: main.c
  group application/crab_lib
    ../src/chemcrab_lib/: craabUtil.c eis.c voltammetry.c
  group application/separate
    ../src/: AfeAdcLib.c AfeDacLib.c AfeTiaLib.c M355_ECSns_DCTest.c
  group common
    ../../aducm355-examples/common/ad5940lib/: ad5940.c
    ../../aducm355-examples/common/: AfeWdtLib.c ClkLib.c CrcLib.c DioLib.c DmaLib.c FeeLib.c GptLib.c I2cLib.c IntLib.c PwrLib.c RstLib.c RtcLib.c SpiLib.c UrtLib.c
  group startup
    ../../aducm355-examples/common/IAR/: retarget.c startup_ADuCM355.c
    ../../aducm355-examples/common/: system_ADuCM355.c
