# IAR project erdc_Template.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ADUCM355 AnalogDevices ADUCM355
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCIncludePath2: ../../../common; ../../../inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: erdc_Template.srec
  ILINK.IlinkOutputFile: erdc_Template.out
  ILINK.IlinkIcfFile: ADuCM355_SRAM_Mode2.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group application
    ../erdc_main/: main_prototype.c
  group application/cyclic_voltammetry
    ../erdc_main/: cycloVoltammetry.c cycloVoltammetry.h
  group application/EIS
    ../erdc_main/: eis.c M355_ECSns_DCTest.c M355_ECSns_DCTest.h M355_ECSns_EIS.h
  group application/square_wave_voltammetry
    ../erdc_main/: square_wave_volt.c
  group common
    ../../../common/: AfeAdcLib.c AfeDacLib.c AfeTiaLib.c AfeWdtLib.c ClkLib.c craabUtil.c DioLib.c GptLib.c IntLib.c M355_ECSns_DCTest.c PwrLib.c RstLib.c UrtLib.c
    ../../../common/IAR/: retarget.c
  group startup
    ../../../common/IAR/: startup_ADuCM355.c
    ../../../common/: system_ADuCM355.c
