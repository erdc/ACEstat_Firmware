# IAR project Backup of chemcrab_main.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ADUCM355 AnalogDevices ADUCM355
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCIncludePath2: ..\..\common; ..\..\inc; ..\src\chemcrab_lib
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: chemcrab_main.srec
  ILINK.IlinkOutputFile: chemcrab_main.out
  ILINK.IlinkIcfFile: ADuCM355_SRAM_Mode2.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group application
    ../src/: main.c
  group application/crab_lib
    ../src/chemcrab_lib/: craabUtil.c eis.c voltammetry.c
  group common
    ../../common/: AfeAdcLib.c AfeDacLib.c AfeTiaLib.c AfeWdtLib.c ClkLib.c DioLib.c GptLib.c IntLib.c M355_ECSns_DCTest.c PwrLib.c RstLib.c UrtLib.c
    ../../common/IAR/: retarget.c
  group startup
    ../../common/IAR/: startup_ADuCM355.c
    ../../common/: system_ADuCM355.c
